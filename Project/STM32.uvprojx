# Keil uVision project STM32.uvprojx, settings and files
target Demo (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32
  c flags: OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,STM32F4_SGA_ENABLE
  c include: ..\Apply\Logic\Inc;..\Apply\Task\Inc;..\Bsp\OCD\Inc;..\Bsp\FatFs\Inc;..\Bsp\Algo\Inc;..\Bsp\Dev\Inc;..\Bsp\RTOS\RT-Thread\include;..\Bsp\RTOS\FreeRTOS\include;..\Bsp\RTOS\FreeRTOS\CMSIS_RTOS_V2;..\Bsp\RTOS\FreeRTOS\portable\RVDS\ARM_CM3;..\Bsp\RTOS\FreeRTOS\portable\RVDS\ARM_CM4F;..\Driver\Inc;..\Hardware\STM32F1XX\CMSIS\Include;..\Hardware\STM32F1XX\CMSIS\Device\ST\STM32F1xx\Include;..\Hardware\STM32F1XX\STM32F1xx_HAL_Driver\Inc;..\Hardware\STM32F1XX\STM32F1xx_HAL_Driver\Inc\Legacy;..\Hardware\STM32F4XX\CMSIS\Include;..\Hardware\STM32F4XX\CMSIS\Device\ST\STM32F4xx\Include;..\Hardware\STM32F4XX\STM32F4xx_HAL_Driver\Inc;..\Bsp\LWIP;..\Bsp\LWIP\arch;..\Bsp\LWIP\src\include;..\Bsp\MALLOC
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Apply/Logic
    ../Apply/Logic/Src/: main.c usercode.c config.c threadpool.c
  group Apply/Task
    ../Apply/Task/Src/: task_irq.c task_sysinit.c task_userinit.c task_lwipudp.c task_powerdetect.c task_serialscreen.c task_can.c task_selfcheck.c
  group Bsp/Algo
    ../Bsp/Algo/Src/: algo_pid.c algo_func.c
  group Bsp/Dev
    ../Bsp/Dev/Src/: dev_ps2.c
  group Bsp/FatFs
    ../Bsp/FatFs/Src/: ff.c diskio.c
  group Bsp/LwIP/arch
    ../Bsp/LWIP/arch/: ethernetif.c lwip_comm.c sys_arch.c
  group Bsp/LwIP/src/api
    ../Bsp/LWIP/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group Bsp/LwIP/src/core
    ../Bsp/LWIP/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../Bsp/LWIP/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group Bsp/LwIP/src/netif
    ../Bsp/LWIP/src/netif/: ethernet.c
  group Bsp/OCD
    ../Bsp/OCD/Src/: ocd_ads1256.c ocd_at24cxx.c ocd_ds3231.c ocd_jy901.c ocd_ms5837.c ocd_oled.c ocd_rm3100.c ocd_ethernet.c ocd_sdcard.c
  group Doc
    ../Doc/: 工程目录介绍.txt 工程维护记录.txt 句柄资源示例.txt
  group Driver
    ../Driver/Src/: drv_hal.c drv_hal_adc.c drv_hal_can.c drv_hal_dac.c drv_hal_delay.c drv_hal_flash.c drv_hal_gpio.c drv_hal_iic_soft.c drv_hal_pwm.c drv_hal_pwr.c drv_hal_spi.c drv_hal_spi_soft.c drv_hal_timer.c drv_hal_uart.c drv_hal_wdg.c
  group FreeRTOS
    ../Bsp/RTOS/FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Bsp/RTOS/FreeRTOS/portable/MemMang/: heap_4.c
    ../Bsp/RTOS/FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ../Bsp/RTOS/FreeRTOS/CMSIS_RTOS_V2/: cmsis_os1.c cmsis_os2.c
  group Hardware
    ../Hardware/STM32F4XX/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ../Hardware/STM32F4XX/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f407xx.s
    ../Hardware/STM32F4XX/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_cec.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_dcmi_ex.c stm32f4xx_hal_dfsdm.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_dsi.c stm32f4xx_hal_eth.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_fmpi2c.c stm32f4xx_hal_fmpi2c_ex.c stm32f4xx_hal_fmpsmbus.c stm32f4xx_hal_fmpsmbus_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hash.c stm32f4xx_hal_hash_ex.c stm32f4xx_hal_hcd.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_irda.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_lptim.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_mmc.c stm32f4xx_hal_nand.c stm32f4xx_hal_nor.c stm32f4xx_hal_pccard.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sai.c stm32f4xx_hal_sai_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_sdram.c stm32f4xx_hal_smartcard.c stm32f4xx_hal_smbus.c stm32f4xx_hal_spdifrx.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_wwdg.c
